options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: test_RSSI_file
    output_language: python
    run_options: run
    title: test_RSSI_file
  states: {}

blocks:
- name: distance
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 2.3e9
  states: {}
- name: file
  id: variable
  parameters:
    value: '"f23_julio"'
  states: {}
- name: fm
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: distance
    type: float
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: fm + 50e3
    low_cutoff_freq: fm - 50e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(samp_rate)
    max_iter: '4000'
    scale: 1/samp_rate
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate)
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    clock_rate: '0.0'
    dc_offs_enb0: auto
    dev_addr: '"serial=31BA199"'
    dev_args: '""'
    gain0: gain_rx
    iq_imbal_enb0: disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '1']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_head_0, '0', blocks_stream_mux_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_skiphead_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_head_0, '0']
- [blocks_skiphead_0, '0', band_pass_filter_0_0, '0']
- [blocks_skiphead_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
